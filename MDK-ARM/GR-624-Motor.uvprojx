# Keil uVision project GR-624-Motor.uvprojx, settings and files
target GR-624-Motor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32C643x4 Puya
  pack: Puya.PY32C643_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GR-624-Motor +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32C643x4,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\Drivers\BSP\PY32C643xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32C6xx\Include;..\Drivers\PY32C643_HAL_Driver\Inc;..\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../Src/: main.c application.c py32c643_it.c
  group Core
    ../Core/: adc.c common.c I2c.c iwdg.c key.c led.c pump.c tim.c timpwm.c gzp6859d.c seg.c uart.c tm1652.c
  group Common
    ./: startup_py32c643xx.s
    ../Src/: system_py32c643.c
  group PY32C643_Start_Kit
    ../Drivers/BSP/PY32C643xx_Start_Kit/: py32c643xx_ll_Start_Kit.c
  group PY32C643_HAL_Driver
    ../Drivers/PY32C643_HAL_Driver/Src/: py32c643_ll_adc.c py32c643_ll_exti.c py32c643_ll_gpio.c py32c643_ll_pwr.c py32c643_ll_rcc.c py32c643_ll_tim.c py32c643_ll_usart.c py32c643_ll_utils.c py32c643_ll_i2c.c
